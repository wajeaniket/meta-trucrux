SRC_URI = "git://github.com/Trucrux/imx-atf.git;protocol=https;branch=${SRCBRANCH}"
SRCBRANCH = "imx_5.4.24_2.1.0"
SRCREV = "06450210f94c10e7298804bcc6498955769ec907"
